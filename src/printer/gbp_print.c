#include <string.h>
#include "gbp_print.h"

// GB 2bpp print font generated by tools/mkfont.py (same glyph codes as screen)
extern const unsigned char font2bpp[128 * 16];

void gbp_render_text_row(const char *chars, int n, uint8_t *out)
{
    for (int t = 0; t < GBP_TILES_PER_ROW; t++) {
        if (t < n) {
            unsigned idx = (uint8_t)chars[t] & 0x7F;
            memcpy(out + t * 16, font2bpp + idx * 16, 16);
        } else {
            memset(out + t * 16, 0, 16);   // color 0 = paper white
        }
    }
}

void gbp_compose_text_page(const char *text, int len, const Layout *lo,
                           int first_line, uint8_t *page)
{
    for (int row = 0; row < GBP_ROWS_PER_PAGE; row++) {
        int ln = first_line + row;
        uint8_t *out = page + row * GBP_ROW_BYTES;
        if (ln < lo->count) {
            int llen = layout_line_len(lo, text, len, ln);
            if (llen > GBP_TILES_PER_ROW)
                llen = GBP_TILES_PER_ROW;  // wrap-overflow spaces are clipped
            gbp_render_text_row(text + lo->start[ln], llen, out);
        } else {
            memset(out, 0, GBP_ROW_BYTES);
        }
    }
}
